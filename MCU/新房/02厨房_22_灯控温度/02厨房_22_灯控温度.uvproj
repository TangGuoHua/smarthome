# Keil uVision project 02厨房_22_灯控温度.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC12C5616AD Series
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: 02厨房_22_灯控温度 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: main.c stcEEPROM.c adc.c nrf24L01.c ds18B20.c
