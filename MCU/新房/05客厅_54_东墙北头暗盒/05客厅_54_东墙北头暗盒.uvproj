# Keil uVision project 05客厅_54_东墙北头暗盒.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12LE5616AD STC12LE5616AD Series
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: 05客厅_54_东墙北头暗盒 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: nrf24L01.c am2321.c main.c
