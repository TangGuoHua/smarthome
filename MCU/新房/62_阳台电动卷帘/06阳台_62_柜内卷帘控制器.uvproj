# Keil uVision project 06阳台_62_柜内卷帘控制器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC12C5616AD Series
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: 06阳台_62_柜内卷帘控制器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: nrf24L01.c main.c BH1750FVI.C ds18B20.c
