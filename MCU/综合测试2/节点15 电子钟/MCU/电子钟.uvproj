# Keil uVision project 电子钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 电子钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: main.c nrf24L01.c adc.c ds18B20.c
