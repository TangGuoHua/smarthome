# Keil uVision project DHT11NODE.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC12C5616AD Series
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: DHT11NODE +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./souce/: nrf24L01.c dht11.c main.c
