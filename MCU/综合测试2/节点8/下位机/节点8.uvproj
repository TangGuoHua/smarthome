# Keil uVision project 节点8.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 节点8 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: nrf24L01.c adc.c dht11.c main.c ds18B20.c
