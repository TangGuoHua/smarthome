# Keil uVision project 32_书房吊顶灯带.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11L04E STC11L01E Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(45000000)
  output: 32_书房吊顶灯带 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: nrf24L01.c main.c stcEEPROM.c
