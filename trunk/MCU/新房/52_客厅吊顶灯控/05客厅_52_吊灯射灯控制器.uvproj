# Keil uVision project 05客厅_52_吊灯射灯控制器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F04E STC11F01E Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(45000000)
  output: 05客厅_52_吊灯射灯控制器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: nrf24L01.c main.c stcEEPROM.c
