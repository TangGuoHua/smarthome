# Keil uVision project 05客厅_53_东墙南头暗盒.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F04E STC11F01E Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(45000000)
  output: 05客厅_53_东墙南头暗盒 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: nrf24L01.c main.c am2321.c
