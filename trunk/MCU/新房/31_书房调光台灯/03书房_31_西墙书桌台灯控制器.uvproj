# Keil uVision project 03书房_31_西墙书桌台灯控制器.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5608AD STC12C5616AD Series
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(45000000)
  output: 03书房_31_西墙书桌台灯控制器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: main.c nrf24L01.c
