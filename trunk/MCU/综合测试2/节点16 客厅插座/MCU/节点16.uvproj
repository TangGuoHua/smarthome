# Keil uVision project 节点16.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5608AD STC12C5616AD Series
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(45000000)
  output: 节点16 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: main.c nrf24L01.c am2301.c
