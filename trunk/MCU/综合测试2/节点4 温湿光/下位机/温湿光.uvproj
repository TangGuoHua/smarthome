# Keil uVision project 温湿光.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 温湿光 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./source/: main.c ds18B20.c delay.c dht11.c adc.c nrf24L01.c am2301.c
