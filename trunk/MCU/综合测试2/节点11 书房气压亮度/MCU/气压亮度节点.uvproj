# Keil uVision project 气压亮度节点.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F04E STC11F01E Series
  cpu: IRAM(0-0xFF) IROM(0-0xFFF) CLOCK(45000000)
  output: 气压亮度节点 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./source/: main.c BH1750FVI.C BMP085.c nrf24L01.c
